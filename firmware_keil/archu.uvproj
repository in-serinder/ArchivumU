# Keil uVision project archu.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C55WD Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x4FFF) CLOCK(24000000)
  output: archu +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\EEPROM;.\Serial;.\Security
  group Root
    ./: main.c
  group Serial
    ./Serial/: Serial.c Serial.h
  group EEPROM
    ./EEPROM/: HW_24c64.c HW_24c64.h
  group Manager
    ./: ConfigMgr.c ConfigMgr.h StorageMgr.c StorageMgr.h
  group Security
    ./Security/: Auth.c Auth.h FeatTag.c FeatTag.h
  group CommandParser
    ./: CommandParser.c CommandParser.h
